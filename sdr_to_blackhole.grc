options:
  parameters:
    generate_options: qt_gui
    id: sdr_to_blackhole
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '3'
  states: {}
- name: effective
  id: variable
  parameters:
    value: (samp_rate * interpolation) // decimation
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    label: frequency
    type: real
    value: '106100000'
  states: {}
- name: interpolation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2304000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: BlackHole 2ch
    num_inputs: '2'
    ok_to_block: 'False'
    samp_rate: effective
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: effective
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decimation
    interp: interpolation
    type: ccc
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    agc: 'True'
    bufflen: '4096'
    center_freq: freq
    gain: '0'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_complex_to_float_0, '1', audio_sink_0, '1']
- [blocks_throttle2_0, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle2_0, '0']
- [soapy_rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
