options:
  parameters:
    generate_options: qt_gui
    id: rtl_to_VAC_HiFi
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: down
  id: variable
  parameters:
    value: '3'
  states: {}
- name: effective
  id: variable
  parameters:
    value: samp_rate * up / down
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    label: Centre Frequency
    type: real
    value: '106100000'
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    label: RF Gain
    type: int
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1152000'
  states: {}
- name: up
  id: variable
  parameters:
    value: '1'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: '"Speakers (VB-Audio Hi-Fi Cable)"'
    num_inputs: '2'
    samp_rate: int(effective)
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2**(-12)
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: down
    interp: up
    type: ccc
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    agc: 'True'
    bufflen: '8192'
    center_freq: freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_complex_to_float_0, '1', audio_sink_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [soapy_rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
